Commit message: adjust for domino

File: predicators/envs/assets/urdf/domino_target.urdf (robot description, URDF)
Before this commit: robot simple_flap, 6 links, 5 joints
Links:
- link flap_panel: mass 0.001 -> 0.005
- link short_flap1: mass 0.001 -> 0.005
- link short_flap2: mass 0.001 -> 0.005
